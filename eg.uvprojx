# Keil uVision project eg.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: eg
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\start;.\user;.\BSP;.\Library
  asm define: STM32F10X_HD
  asm include: .\start;.\user;.\BSP;.\Library
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group start
    ./start/: startup_stm32f10x_hd.s system_stm32f10x.c
  group user
    ./user/: main.c stm32f10x_it.c
  group BSP
    ./BSP/: delay.c lcd_st7789v_16bit.c font5x7.c touch_xpt2046.c
  group Library
    ./Library/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
